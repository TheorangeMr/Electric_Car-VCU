# Keil uVision project BAJA_E_VCU1.0.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BAJA_E_VCU1.0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\BSP\ADC;..\BSP\CAN;..\BSP\HGW_Protocol;..\FreeRtos\include;..\FreeRtos\portable\ARM_CM3;..\Library\CMSIS;..\Library\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\delay;..\User\sys;..\User\USART;..\User\delay-FreeRTOS;..\BSP\wit_c_sdk;..\BSP\dangwei
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Library/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Library/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWILB
    ../Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c FreeRTOSConfig.h stm32f10x_conf.h stm32f10x_it.c
    ../User/USART/: usart.c
    ../User/delay-FreeRTOS/: bsp_delay.c
  group BSP
    ../BSP/ADC/: adc.c
    ../BSP/CAN/: can.c
    ../BSP/HGW_Protocol/: HGW_Protocol.c
    ../BSP/wit_c_sdk/: wit_c_sdk.c
    ../BSP/dangwei/: dangwei.c
  group FreeRTOS/source
    ../FreeRtos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRtos/portable/ARM_CM3/: port.c
    ../FreeRtos/portable/MemMang/: heap_4.c
  group DOC
    ../Doc/: readme.txt
